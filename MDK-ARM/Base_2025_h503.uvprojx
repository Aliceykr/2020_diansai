# Keil uVision project Base_2025_h503.uvprojx, settings and files
target Base_2025_h503 (6240000::V6.24::ARMCLANG)
  device: STM32H503CBTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x801FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: Base_2025_h503 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H503xx
  c include: ../Core/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Drivers/CMSIS/Include;../User;../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32h503xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c gpdma.c i2c.c icache.c opamp.c spi.c tim.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_adc.c stm32h5xx_hal_adc_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_cortex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_icache.c stm32h5xx_hal_opamp.c stm32h5xx_hal_opamp_ex.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group User
    ../User/: oled.c oled.h ad9833.c ad9833.h
software components: CMSIS:CORE 4.3.0
